# Keil uVision project LPC1114_project.uvprojx, settings and files
target LPC1114 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1114_project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\adc;..\delay;..\key;..\uart;..\1602;..\MF52
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user
    ./user/: main.c
  group 1602
    ../1602/: 1602.c
  group adc
    ../adc/: adc.c
  group delay
    ../delay/: delay.c
  group uart
    ../uart/: uart.c
  group MF52
    ../MF52/: MF52.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
